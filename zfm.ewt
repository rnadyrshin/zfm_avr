<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>delay</name>
    <file>
      <name>$PROJ_DIR$\delay\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\delay\delay.h</name>
    </file>
  </group>
  <group>
    <name>timers</name>
    <file>
      <name>$PROJ_DIR$\timers\timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timers\tmr2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timers\tmr2.h</name>
    </file>
  </group>
  <group>
    <name>uart</name>
    <file>
      <name>$PROJ_DIR$\uart\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart\uart.h</name>
    </file>
  </group>
  <group>
    <name>zfm</name>
    <file>
      <name>$PROJ_DIR$\zfm\zfm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\zfm\zfm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\zfm\zfm_cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\zfm\zfm_cmd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\zfm\zfm_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\zfm\zfm_common.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
</project>


